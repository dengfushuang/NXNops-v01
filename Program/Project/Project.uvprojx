# Keil uVision project Project.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  BeforeCompile: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x00006000 --output=E:\Work\NXNops-v01\Program\Bin\app.bin E:\Work\NXNops-v01\Program\Output\Project.axf
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: ..\Libraries\Core;..\Libraries\Device\include;..\Startup;..\User;..\ucOSII2.91\Config;..\ucOSII2.91\Ports;..\ucOSII2.91\Source;..\ucOSII2.91\Cpu;..\Hardware\uart;..\Hardware\led;..\Hardware\74hc595;..\Hardware\lcd16032;..\Hardware\delay;..\uip\lib;..\uip\arch\STM32;..\uip\src;..\uip\app;..\uip\app\http;..\Hardware\DP83848;..\Hardware\ADC;..\Hardware\OSW;..\Hardware\RTC;..\Hardware\AT24C512;..\Hardware\eeprom;..\Hardware\DS18B20;..\Hardware\I2C;..\Drivers\source;..\Hardware\sim800c
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: OS_AppHooks.c User_TimeTicks.c main.c cmd_process.c user_Task.c function.c
  group Hardware
    ../Hardware/eeprom/: lpc177x_8x_eeprom.c
    ../Hardware/delay/: delay.c
    ../Hardware/uart/: queue.c uart0.c uart1.c uart2.c
  group Startup
    ../Startup/: startup_LPC17xx.s
  group Libraries/core
    ../Libraries/Core/: core_cm3.c LPC177x_8x.h system_LPC177x_8x.c
  group ucOS/Ports
    ../ucOSII2.91/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group ucOS/Source
    ../ucOSII2.91/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucOS/Config
    ../ucOSII2.91/Config/: os_cfg.h
software components: CMSIS:CORE 4.3.0
